options:
  parameters:
    author: Team-XX
    generate_options: qt_gui
    id: lab01_loopback
    output_language: python
    title: Lab 01 - Loopback (TX1 -> RX1 cable)
  states: {}

blocks:
- name: f_tune
  id: variable
  parameters:
    value: int(fc + lo_shift)
  states: {}
- name: f_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: f_tx (Hz)
    start: '-1e6'
    step: 50e3
    stop: 1e6
    value: 250e3
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: fc (Hz)
    start: 325e6
    step: 16e6
    stop: 3.8e9
    value: 434e6
    widget: counter
  states: {}
- name: lo_shift
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: lo_shift (Hz)
    start: '-500e3'
    step: 10e3
    stop: 500e3
    value: '0'
  states: {}
- name: rec
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 1,0,1,1
    label: Record I/Q
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rec_sec
  id: variable
  parameters:
    value: min(4.0, 80e6/(8*samp_rate))
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '10'
    value: '10'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample rate
    label0: '"2.6 MS/s"'
    label1: '"5 MS/s"'
    label2: '"10 MS/s"'
    label3: '"20 MS/s"'
    num_opts: '4'
    option0: '2600000'
    option1: '5000000'
    option2: '10000000'
    option3: '20000000'
    type: int
    value: '2600000'
  states: {}
- name: team
  id: variable
  parameters:
    value: '"Team-XX"'
  states: {}
- name: tx_att
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: TX1 attenuation (dB)
    start: '40'
    step: '1'
    stop: '89'
    value: '60'
  states: {}
- name: uri
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: f_tune
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,4
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: iq_recorder
  id: epy_block
  parameters:
    _source_code: |
      """
      SDR Lab IQ Recorder -- Embedded Python Block (GNU Radio 3.10)

      Records raw complex64 I/Q samples to
          teamID_labNN_fc_fs_gain_timestamp.cf32
      e.g. Team-07_lab01_945000000_2600000_20.0_20261005T101502.cf32

      States (Lab 01 manual, Fig. 8):
          IDLE      -- no file open; record = True opens a new file -> RECORDING
          RECORDING -- file open; closes when
                         (a) record -> False                     -> IDLE
                         (b) floor(max_seconds * fs) samples hit -> WAIT
                         (c) fc / fs / gain changed              -> WAIT
                         (d) flowgraph stopped (stop())
          WAIT      -- file closed automatically; waits for record -> False
                       so that no new file is opened by itself  -> IDLE

      Paste this file into an Embedded Python Block (Open in Editor) and set:
          team, lab, fc=f_tune, fs=samp_rate, gain=rf_gain, record=rec,
          max_seconds=rec_sec, folder="recordings"
      """

      import os
      import time

      import numpy as np
      from gnuradio import gr

      IDLE, RECORDING, WAIT = 'IDLE', 'RECORDING', 'WAIT'


      class blk(gr.sync_block):
          """SDR Lab IQ Recorder: writes raw complex64 I/Q (.cf32) with the
          standard lab file name. Tick `record` to start; the file closes when
          the tick is removed, after max_seconds, when fc/fs/gain change, or
          when the flowgraph stops."""

          def __init__(self, team='Team-00', lab=1, fc=100e6, fs=2.6e6, gain=0.0,
                       record=False, max_seconds=5.0, folder='.'):
              gr.sync_block.__init__(
                  self,
                  name='SDR Lab IQ Recorder',
                  in_sig=[np.complex64],
                  out_sig=None,
              )
              # Same names as the arguments, so GRC callbacks update them at run time.
              self.team = team
              self.lab = lab
              self.fc = fc
              self.fs = fs
              self.gain = gain
              self.record = record
              self.max_seconds = max_seconds
              self.folder = folder

              self._state = IDLE
              self._file = None
              self._path = ''
              self._settings = None    # (fc, fs, gain) at the moment the file opened
              self._target = 0         # floor(max_seconds * fs)
              self._written = 0

          # ---------------------------------------------------------------- helpers
          def _current_settings(self):
              return (int(round(float(self.fc))),
                      int(round(float(self.fs))),
                      round(float(self.gain), 1))

          def _open(self):
              fc, fs, gain = self._settings = self._current_settings()
              folder = str(self.folder) or '.'
              os.makedirs(folder, exist_ok=True)
              stamp = time.strftime('%Y%m%dT%H%M%S')
              name = '{}_lab{:02d}_{}_{}_{:.1f}_{}.cf32'.format(
                  self.team, int(self.lab), fc, fs, gain, stamp)
              self._path = os.path.join(folder, name)
              self._file = open(self._path, 'wb')
              self._target = int(np.floor(float(self.max_seconds) * fs))
              self._written = 0
              self._state = RECORDING
              print('[REC] start {}'.format(name), flush=True)

          def _close(self, reason, next_state):
              if self._file is not None:
                  self._file.close()
                  self._file = None
                  fs = self._settings[1] if self._settings else float(self.fs)
                  print('[REC] stop  {} samples = {:.2f} s ({})'.format(
                      self._written, self._written / fs, reason), flush=True)
              self._state = next_state

          # ------------------------------------------------------------------- work
          def work(self, input_items, output_items):
              x = input_items[0]
              record = bool(self.record)

              if self._state == IDLE:
                  if record:
                      self._open()
              elif self._state == WAIT:
                  if not record:
                      self._state = IDLE

              if self._state == RECORDING:
                  if not record:
                      self._close('record unchecked', IDLE)
                  elif self._current_settings() != self._settings:
                      # This buffer already belongs to the new settings: do not write it.
                      self._close('fc/fs/gain changed', WAIT)
                  else:
                      n = min(len(x), self._target - self._written)
                      if n > 0:
                          x[:n].astype(np.complex64, copy=False).tofile(self._file)
                          self._written += n
                      if self._written >= self._target:
                          self._close('max_seconds reached', WAIT)

              return len(x)

          def stop(self):
              self._close('flowgraph stopped', IDLE)
              return True
    fc: f_tune
    folder: '"recordings"'
    fs: samp_rate
    gain: rf_gain
    lab: '1'
    max_seconds: rec_sec
    record: rec
    team: team
  states: {}
- name: pluto_sink
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_att
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Off'''
    frequency: int(fc)
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: pluto_source
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Off'''
    frequency: f_tune
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,0,1,4
    name: '"Time (I/Q)"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: tone
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: f_tx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: waterfall_sink
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: f_tune
    fftsize: '1024'
    gui_hint: 3,0,1,4
    int_max: '-20'
    int_min: '-110'
    name: '"Waterfall"'
    type: complex
  states: {}

connections:
- [pluto_source, '0', freq_sink, '0']
- [pluto_source, '0', iq_recorder, '0']
- [pluto_source, '0', time_sink, '0']
- [pluto_source, '0', waterfall_sink, '0']
- [tone, '0', pluto_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
